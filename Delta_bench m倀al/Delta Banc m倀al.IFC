Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Delta Banc métal.IFC
Time: 2020-06-29T07:26:40
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DELT-BANC-MUL-001_Default
In: Default Storey
Material: FGS 400-15

# IfcBeam: KAPSTO-GPN320GL38_Default (2)
In: Default Storey
Material: PE faible/moyenne densité

# IfcBeam: MULT-MUL-004_Default (2)
In: Default Storey
Name
MULT-MUL-004_Default | PSet_Mass_Property - Mass Measure: 207.668; Area Measure: 5.15473; Volume Measure: 0.0711942
MULT-MUL-004_Default

# IfcBeam: MULT-SCE-002_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: MULT-SCE-002_Default
In: Default Storey
Material: S235
